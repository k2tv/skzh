# IAR project SerialApp.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: HAL_UART=TRUE; SERIAL_APP_PORT=0; COOR; xLCD_SUPPORTED; NV_INIT
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Public; ..\..\..\..\..\Components\uCGUI\Core; ..\..\..\..\..\Components\uCGUI\MultiLayer; ..\..\..\..\..\Components\uCGUI\Config; ..\Coordinator; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration Motor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; POWER_SAVING; NV_INIT; NV_RESTORE; MOTOR
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Motor; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration Shake (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; POWER_SAVING; NV_INIT; NV_RESTORE; SHAKE
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Shake; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration Smoke (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; xPOWER_SAVING; NV_INIT; NV_RESTORE; SMOKE; OSC32K_CRYSTAL_INSTALLED=FALES
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Smoke; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration Hall (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; POWER_SAVING; NV_INIT; NV_RESTORE; HALL
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Hall; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration Touch (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; POWER_SAVING; NV_INIT; TOUCH
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Touch; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration PWM (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; xPOWER_SAVING; NV_INIT; PWM
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\PWM; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration Ultrasound (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; xPOWER_SAVING; NV_INIT; NV_RESTORE; ULTRASOUND
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Ultrasound; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration Relay (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; xPOWER_SAVING; NV_INIT; NV_RESTORE; RELAY
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Relay; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration TempHumLight (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; POWER_SAVING; NV_INIT; TEMPANDHUM
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\TempAndHum; ..\Public; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
configuration PIR (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration Voltage (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration VoltageOut (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; xSERIAL_APP_PORT=0; xPOWER_SAVING; NV_INIT; NV_RESTORE; RELAY
  ICC8051.CCIncludePath2: as above
configuration Current (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; HAL_UART=TRUE; SERIAL_APP_PORT=0; POWER_SAVING; NV_INIT; NV_RESTORE; RELAY
  ICC8051.CCIncludePath2: as above
configuration MilliVoltMeter (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration FM1702SL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration Dioxidecar (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration Rain (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration Accele (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  group App/Accele
    ../Accele/: Accele.c Accele.h
  group App/Coordinator
    ../Coordinator/: Coordinator.c
  group App/Current
    ../Currentt/: Currentt.c
  group App/Dioxidecar
    ../Dioxidecar/: Dioxidecar.c Dioxidecar.h
  group App/FM1702SL
    ../FM1702SL/: FM1702SL.c SPI.c
  group App/Hall
    ../Hall/: Hall.c Hall.h
  group App/MilliVoltMeter
    ../MilliVoltMeter/: MilliVoltMeter.c MilliVoltMeter.h
  group App/Motor
    ../Motor/: Motor.c motor.h
  group App/PIR
    ../PIR/: PIR.c PIR.h
  group App/PWM
    ../PWM/: PWM.c PWM.h
  group App/Rain
    ../Rain/: Rain.c Rain.h
  group App/Relay
    ../Relay/: Relay.c Relay.h
  group App/Shake
    ../Shake/: Shake.c Shake.h
  group App/Smoke
    ../Smoke/: Smoke.c Smoke.h
  group App/TempHumLight
    ../Public/: HumiTemp.c
    ../TempHumLight/: TempHumLight.c TempHumLight.h
  group App/Touch
    ../Touch/: Touch.c Touch.h
  group App/Ultrasound
    ../Ultrasound/: Ultrasound.c Ultrasound.h
  group App/Voltage
    ../Voltage/: Voltage.c
  group App/VoltageOut
    ../VoltageOut/: VoltageOut.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
  group Public
    ../Public/: hal.h iic.c OSAL_SerialApp.c Relay.h Touch.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
